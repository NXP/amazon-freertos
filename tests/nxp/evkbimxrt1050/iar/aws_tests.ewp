# IAR project aws_tests.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; HIGH_SPEED_SDIO_CLOCK=1; USE_RTOS=1; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; UNITY_INCLUDE_CONFIG_H=1; FSL_RTOS_FREE_RTOS; WIFI_WICED
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ../../../../lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/IAR/ARM_CM4F; ../../../common/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/CMSIS/Include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/mbedtls/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/mbedtls/port/ksdk; ../../../../lib/include; ../../../../lib/include/private; ../common; ../../../../lib/include; ../../../../lib/third_party/unity/src; ../../../../lib/third_party/unity/extras/fixture/src; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers; ../common/config_files; ../common/application_code/nxp_code; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers; ../../../../lib/third_party/pkcs11; ../../../../lib/third_party/jsmn; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/platforms/NEB1DX_01; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/port; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/port; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/port; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/FreeRTOS-Plus-TCP/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/utilities/str; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/utilities/debug_console; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/uart; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/serial_manager; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/serial_manager; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/lists; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/xip; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/boards/evkbimxrt1050/xip; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/lwip; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/inc; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/src; ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../common/config_files
  ILINK.IlinkOutputFile: aws_tests.out
  ILINK.IlinkConfigDefines: __stack_size__=0x200; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; CPU_MIMXRT1052DVL6B; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; HIGH_SPEED_SDIO_CLOCK=1; USE_RTOS=1; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; UNITY_INCLUDE_CONFIG_H=1; FSL_RTOS_FREE_RTOS; WIFI_WICED
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group application_code
    ../common/application_code/: main.c
    ../../../../demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group application_code/common-tests/crypto
    ../../../common/crypto/: aws_test_crypto.c
  group application_code/common-tests/framework
    ../../../common/framework/: aws_test_framework.c
  group application_code/common-tests/greengrass
    ../../../common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group application_code/common-tests/include
    ../../../common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_logging_task.h aws_mqtt_lib_test_access_declare.h aws_mqtt_lib_test_access_define.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_tls.h aws_test_utils.h
    ../../../../lib/include/: aws_appversion32.h
  group application_code/common-tests/memory_leak
    ../../../common/memory_leak/: aws_memory_leak.c
  group application_code/common-tests/mqtt
    ../../../common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group application_code/common-tests/pkcs11
    ../../../common/pkcs11/: aws_test_pkcs11.c
  group application_code/common-tests/secure_sockets
    ../../../common/secure_sockets/: aws_test_tcp.c
  group application_code/common-tests/shadow
    ../../../common/shadow/: aws_test_shadow.c
  group application_code/common-tests/test_runner
    ../../../common/test_runner/: aws_test_runner.c
  group application_code/common-tests/tls
    ../../../common/tls/: aws_test_tls.c
  group application_code/common-tests/wifi
    ../../../common/wifi/: aws_test_wifi.c
  group application_code/common-tests/logging
    ../../../../demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group application_code/nxp_code
    ../common/: lwipopts.h
    ../common/application_code/nxp_code/: pin_mux.c pin_mux.h clock_config.h clock_config.c
  group application_code/nxp_code/application_code/nxp_code
    ../common/application_code/nxp_code/: board.c board.h
  group lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c unity.h unity_internals.h
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group lib/third_party/mcu_vendors/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group lib/third_party/mcu_vendor/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/drivers/: fsl_trng.c fsl_trng.h fsl_dcp.c fsl_dcp.h fsl_cache.c fsl_cache.h fsl_flexspi.c fsl_flexspi.h fsl_usdhc.c fsl_usdhc.h fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.h fsl_aoi.c fsl_bee.c fsl_bee.h fsl_clock.h fsl_clock.c fsl_cmp.c fsl_cmp.h fsl_common.h fsl_common.c fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dmamux.h fsl_dmamux.c fsl_edma.h fsl_edma.c fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.h fsl_enet.c fsl_ewm.c fsl_ewm.h fsl_flexcan.h fsl_flexcan.c fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_gpc.c fsl_gpc.h fsl_gpt.c fsl_gpt.h fsl_gpio.h fsl_gpio.c fsl_iomuxc.h fsl_kpp.h fsl_kpp.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.h fsl_lpspi_edma.c fsl_lpuart.h fsl_lpuart.c fsl_lpuart_edma.h fsl_lpuart_edma.c fsl_pit.c fsl_pit.h fsl_pmu.h fsl_pmu.c fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.h fsl_rtwdog.c fsl_sai.h fsl_sai.c fsl_sai_edma.h fsl_sai_edma.c fsl_semc.h fsl_semc.c fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.h fsl_spdif.c fsl_spdif_edma.h fsl_spdif_edma.c fsl_src.c fsl_src.h fsl_tempmon.h fsl_tempmon.c fsl_tsc.c fsl_tsc.h fsl_wdog.h fsl_wdog.c fsl_xbara.h fsl_xbara.c fsl_xbarb.h fsl_xbarb.c fsl_flexio.c fsl_flexio.h
  group lib/third_party/mcu_vendor/43xxx_wifi/platforms/NEB1DX_01
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/platforms/NEB1DX_01/: wifi_nvram_image.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/: generated_mac_address.txt
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/: wwd.h wwd_wiced.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/internal
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/internal/chips/4343W
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_mfg.h 4343WA1_clm_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/internal/bus_protocols
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/include
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/include/network
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/include/platform
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/WWD/include/RTOS
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/network/LwIP/WWD
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/platform
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/: platform_toolchain.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/platform/include
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/platform/MCU
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/platform/MCU/LPC
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/platform/MCU/LPC/WWD
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group lib/third_party/mcu_vendor/43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group lib/third_party/mcu_vendor/43xxx_wifi/include
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/include/: wiced_resource.h
  group lib/third_party/mcu_vendor/43xxx_wifi/internal
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/wiced/43xxx_Wi-Fi/WICED/internal/: wifi.c
  group lib/third_party/mcu_vendor/lwip/port
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/port/: sys_arch.c
  group lib/third_party/mcu_vendor/lwip/port/arch
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lib/third_party/mcu_vendor/lwip/src/api
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/third_party/mcu_vendor/lwip/src/core
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lib/third_party/mcu_vendor/lwip/src/core/ipv4
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lib/third_party/mcu_vendor/lwip/src/core/ipv6
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/compat/posix/: netdb.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/arpa
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/net
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/compat/posix/net/: if.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/sys
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/stdc
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/compat/stdc/: errno.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip/priv
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip/prot
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif/ppp
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif/ppp/polarssl
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lib/third_party/mcu_vendor/lwip/src/netif
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lib/third_party/mcu_vendor/lwip/src/netif/ppp
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lib/third_party/mcu_vendor/sdmmc/src
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group lib/third_party/mcu_vendor/sdmmc/inc
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/inc/: fsl_sdio.h fsl_sdmmc_host.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group lib/third_party/mcu_vendor/sdmmc/port
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/sdmmc/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_include
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_source
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_port
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group lib/third_party/mcu_vendor/device
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group lib/third_party/mcu_vendor/utilities
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/utilities/str/: fsl_str.c fsl_str.h
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/utilities/: fsl_assert.c
  group lib/third_party/mcu_vendor/component/uart
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/uart/: uart.h lpuart_adapter.c
  group lib/third_party/mcu_vendor/component/serial_manager
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group lib/third_party/mcu_vendor/component/lists
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/components/lists/: generic_list.h generic_list.c
  group lib/third_party/mcu_vendor/startup
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group lib/third_party/mcu_vendor/xip
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/devices/MIMXRT1052/xip/: fsl_flexspi_nor_boot.h fsl_flexspi_nor_boot.c
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/boards/evkbimxrt1050/xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h
  group lib/third_party/mcu_vendor/CMSIS
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/CMSIS/Include/: core_cm7.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group lib/third_party/pkcs11
    ../../../../lib/third_party/pkcs11/: pkcs11t.h pkcs11f.h pkcs11.h
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/aws/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group lib/aws/wifi
    ../../../../lib/wifi/portable/nxp/wiced/: aws_wifi.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/nxp/lwip/: aws_secure_sockets.c
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/tls
    ../../../../lib/tls/: aws_tls.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../lib/pkcs11/portable/nxp/common/: aws_pkcs11_pal.c
  group lib/aws/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/aws/FreeRTOS/portable
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../lib/FreeRTOS/portable/: readme.txt
    ../../../../lib/third_party/mcu_vendor/nxp/MIMXRT1052/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h
    ../../../../lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group lib/aws/license
    ../../../../: LICENSE
  group lib/aws/include
    ../../../../lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h mpu_prototypes.h portable.h projdefs.h stack_macros.h threading_alt.h
  group config_files
    ../common/config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h unity_config.h
