# IAR project aws_tests.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; USE_RTOS=1; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; UNITY_INCLUDE_CONFIG_H=1; FRDM_K64F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa084
  ICCARM.CCIncludePath2: ../../../../lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/IAR/ARM_CM4F; ../../../common/include; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12//CMSIS/Include; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mmcau; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mbedtls/include; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mbedtls/port/ksdk; ../../../../lib/include; ../../../../lib/include/private; ../common; ../../../../lib/include; ../../../../lib/third_party/unity/src; ../../../../lib/third_party/unity/extras/fixture/src; ../common/config_files; ../common/application_code/nxp_code; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/phyksz8081; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/pkcs11; ../../../../lib/third_party/jsmn; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/port; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include; ../../../../lib/FreeRTOS-Plus-TCP/include; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/utilities/str; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/utilities/debug_console; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/uart; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/serial_manager; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/serial_manager; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/lists; ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ../common/config_files
  ILINK.IlinkOutputFile: aws_tests.out
  ILINK.IlinkConfigDefines: __stack_size__=0x200; __heap_size__=0x200
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash_data.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mmcau/asm-cm4-cm7/lib_mmcau.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; SDK_DEBUGCONSOLE=1; SDK_I2C_BASED_COMPONENT_USED=1; USE_RTOS=1; LWIP_NETIF_API=1; MEMP_NUM_NETCONN=4; AMAZON_FREERTOS_ENABLE_UNIT_TESTS=1; UNITY_INCLUDE_CONFIG_H=1; FRDM_K64F; FREEDOM; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group application_code
    ../common/application_code/: main.c
    ../../../../demos/common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group application_code/common-tests/crypto
    ../../../common/crypto/: aws_test_crypto.c
  group application_code/common-tests/framework
    ../../../common/framework/: aws_test_framework.c
  group application_code/common-tests/greengrass
    ../../../common/greengrass/: aws_test_greengrass_discovery.c aws_test_helper_secure_connect.c
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group application_code/common-tests/include
    ../../../common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_test_access_declare.h aws_greengrass_discovery_test_access_define.h aws_logging_task.h aws_mqtt_lib_test_access_declare.h aws_mqtt_lib_test_access_define.h aws_test_framework.h aws_test_runner.h aws_test_tcp.h aws_test_tls.h aws_test_utils.h
    ../../../../lib/include/: aws_appversion32.h
  group application_code/common-tests/memory_leak
    ../../../common/memory_leak/: aws_memory_leak.c
  group application_code/common-tests/mqtt
    ../../../common/mqtt/: aws_test_mqtt_agent.c aws_test_mqtt_lib.c
  group application_code/common-tests/pkcs11
    ../../../common/pkcs11/: aws_test_pkcs11.c
  group application_code/common-tests/secure_sockets
    ../../../common/secure_sockets/: aws_test_tcp.c
  group application_code/common-tests/shadow
    ../../../common/shadow/: aws_test_shadow.c
  group application_code/common-tests/test_runner
    ../../../common/test_runner/: aws_test_runner.c
  group application_code/common-tests/tls
    ../../../common/tls/: aws_test_tls.c
  group application_code/common-tests/logging
    ../../../../demos/common/logging/: aws_logging_task_dynamic_buffers.c
  group application_code/nxp_code
    ../common/: lwipopts.h
    ../common/application_code/nxp_code/: pin_mux.c pin_mux.h clock_config.h clock_config.c
  group application_code/nxp_code/application_code/nxp_code
    ../common/application_code/nxp_code/: board.c board.h
  group lib/third_party/unity
    ../../../../lib/third_party/unity/src/: unity.c unity.h unity_internals.h
    ../../../../lib/third_party/unity/extras/fixture/src/: unity_fixture.c unity_fixture.h unity_fixture_internals.h unity_fixture_malloc_overrides.h
  group lib/third_party/mcu_vendor/board
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/phyksz8081/: fsl_phy.h fsl_phy.c
  group lib/third_party/mcu_vendor/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/drivers/: fsl_rnga.c fsl_rnga.h fsl_enet.h fsl_enet.c fsl_ftfx_adapter.h fsl_ftfx_utilities.h fsl_ftfx_features.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_flash.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_port.h fsl_uart.h fsl_uart.c fsl_smc.h fsl_smc.c fsl_common.h fsl_common.c
  group lib/third_party/mcu_vendor/mmcau/mmcau_include
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mmcau/: cau_api.h fsl_mmcau.h
  group lib/third_party/mcu_vendor/mmcau/mmcau_source
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mmcau/: fsl_mmcau.c
  group lib/third_party/mcu_vendor/lwip/port
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
  group lib/third_party/mcu_vendor/lwip/port/arch
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/port/arch/: cc.h perf.h sys_arch.h
  group lib/third_party/mcu_vendor/lwip/src/api
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/third_party/mcu_vendor/lwip/src/core
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lib/third_party/mcu_vendor/lwip/src/core/ipv4
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lib/third_party/mcu_vendor/lwip/src/core/ipv6
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/compat/posix/: netdb.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/arpa
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/compat/posix/arpa/: inet.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/net
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/compat/posix/net/: if.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/posix/sys
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/compat/posix/sys/: socket.h
  group lib/third_party/mcu_vendor/lwip/src/include/compat/stdc
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/compat/stdc/: errno.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip/priv
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lib/third_party/mcu_vendor/lwip/src/include/lwip/prot
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif/ppp
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lib/third_party/mcu_vendor/lwip/src/include/netif/ppp/polarssl
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lib/third_party/mcu_vendor/lwip/src/netif
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lib/third_party/mcu_vendor/lwip/src/netif/ppp
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_include
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md_internal.h md2.h md4.h md5.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs5.h pkcs11.h pkcs12.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_source
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c chacha20.c chachapoly.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/mcu_vendor/mbedtls/mbedtls_port
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/middleware/mbedtls/port/ksdk/: ksdk_mbedtls.c ksdk_mbedtls.h ksdk_mbedtls_config.h sha1_alt.h sha256_alt.h des_alt.h des_alt.c aes_alt.h aes_alt.c ecp_alt.h ecp_alt.c ecp_curves_alt.c ecp_alt_ksdk.c
  group lib/third_party/mcu_vendor/utilities
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/utilities/: fsl_assert.c
  group lib/third_party/mcu_vendor/device
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group lib/third_party/mcu_vendor/component/uart
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/uart/: uart.h uart_adapter.c
  group lib/third_party/mcu_vendor/component/serial_manager
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group lib/third_party/mcu_vendor/component/lists
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/components/lists/: generic_list.h generic_list.c
  group lib/third_party/mcu_vendor/startup
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/devices/MK64F12/iar/: startup_MK64F12.s
  group lib/third_party/mcu_vendor/CMSIS
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
  group lib/third_party/pkcs11
    ../../../../lib/third_party/pkcs11/: pkcs11t.h pkcs11f.h pkcs11.h
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/aws/drivers
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/drivers/: mflash_drv.h mflash_drv.c mflash_file.h mflash_file.c
  group lib/aws/secure_sockets
    ../../../../lib/secure_sockets/portable/nxp/lwip/: aws_secure_sockets.c
  group lib/aws/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/aws/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/aws/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/aws/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/aws/tls
    ../../../../lib/tls/: aws_tls.c
  group lib/aws/pkcs11
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
    ../../../../lib/pkcs11/portable/nxp/common/: aws_pkcs11_pal.c
  group lib/aws/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group lib/aws/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/aws/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/aws/FreeRTOS/portable
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../lib/FreeRTOS/portable/: readme.txt
    ../../../../lib/third_party/mcu_vendor/nxp/MK64F12/IAR/ARM_CM4F/: fsl_tickless_systick.c fsl_tickless_generic.h
    ../../../../lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group lib/aws/license
    ../../../../: LICENSE
  group lib/aws/include
    ../../../../lib/include/: event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
    ../../../../lib/include/private/: deprecated_definitions.h list.h mpu_wrappers.h mpu_prototypes.h portable.h projdefs.h stack_macros.h threading_alt.h
  group config_files
    ../common/config_files/: aws_bufferpool_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_test_pkcs11_config.h aws_test_runner_config.h aws_test_tcp_config.h aws_test_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h unity_config.h
